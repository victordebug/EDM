# Keil uVision project template.uvprojx, settings and files
target template (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103ZC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: theGodofFire +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\lib\FWLIB\inc;..\lib\CMSIS;..\user;..\dirver;..\UCOSII\CONFIG;..\UCOSII\CORE;..\UCOSII\PORT;..\BSP;..\APP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group startup
    ../lib/CMSIS/startup/arm/: startup_stm32f10x_hd.s
  group cmsis
    ../lib/CMSIS/: core_cm3.c stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group fwlib
    ../lib/FWLIB/src/: stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c stm32f10x_adc.c misc.c
    ../lib/FWLIB/inc/: stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h misc.h
  group user
    ../user/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h Command.c Frame.c ADC.c CMD_GetStateEx.c Memory_Copy.c SystemState.c beep.c edm.c eeprom_24lc16b.c led.c motor.c voltage.c data_analy.c myString.c
  group UCOSII-PORT
    ../UCOSII/PORT/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
  group UCOSII-CORE
    ../UCOSII/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group UCOSII-CONFIG
    ../UCOSII/CONFIG/: os_cfg.h includes.h
  group BSP
    ../BSP/: bsp.c bsp.h
  group driver
    ../dirver/: queue.c queue.h systick.c systick.h uart.c uart.h GPIO.c adc.c fsmc.c i2c.c pwm.c dma.c dac.c dac_7611ub.c
  group APP
    ../APP/: app.c
software components: CMSIS:CORE 5.0.1
